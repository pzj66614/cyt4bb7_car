/*********************************************************************************************************************
* 文件名称          trans.c
* 功能说明          将图像横向偏差 offset 转换为目标航向角修正 yaw
*
* 适用场景：
* 1. 项目一绕桩
* 2. 没有明确赛道宽度，仅依赖锥桶相对图像中心的位置进行转向控制
*
* 设计思路：
* 1. 不再使用 track_width
* 2. 用小孔成像近似：yaw = atan(offset / fx)
* 3. 增加工程调参项：
*    - 中心死区：防抖
*    - 增益：控制灵敏度
*    - 限幅：防止转向过猛
*    - 分段增益：小偏差灵敏，大偏差柔和
*********************************************************************************************************************/

#include "trans.h"
#include <math.h>

//====================================================
// 一、需要根据现场调试的参数
//====================================================

/*
 * 图像宽度（单位：像素）
 * 必须与你实际摄像头输出宽度一致
 * 例如 MT9V03X 常见为 188
 */
#define PROJECT_ONE_IMAGE_W         (188.0f)

/*
 * 摄像头水平视场角 HFOV（单位：度）
 * 含义：摄像头左右总共能看到多少度
 *
 * 典型范围：
 * 50 ~ 70 度
 *
 * 建议初值：
 * 60 度
 *
 * 如果你不知道准确值，先用 60.0f 调试即可
 * 后续一般优先调 YAW_GAIN，而不是频繁改 HFOV
 */
#define CAMERA_HFOV_DEG             (120.0f)

/*
 * 中心死区（单位：像素）
 * 含义：当目标已经接近图像中心时，不再输出 yaw，避免车左右小抖
 *
 * 调大：
 *   - 中心更稳
 *   - 但可能略迟钝
 *
 * 调小：
 *   - 更灵敏
 *   - 但更容易抖动
 *
 * 建议范围：
 * 2 ~ 5
 */
#define OFFSET_DEADBAND_PX          (3)

/*
 * 全局增益
 * 含义：放大/缩小 atan 得到的几何角度
 *
 * 调大：
 *   - 转向更积极
 *   - 容易猛摆
 *
 * 调小：
 *   - 转向更柔和
 *   - 容易转不过去
 *
 * 建议初值：
 * 1.0 ~ 1.3
 */
#define YAW_GAIN                    (1.10f)

/*
 * 最大允许输出的 yaw（单位：度）
 * 含义：防止大偏差时一次给太大角度，导致车辆猛摆
 *
 * 调大：
 *   - 大偏差时更容易转回来
 *   - 但可能动作过猛
 *
 * 调小：
 *   - 更稳
 *   - 但可能修不过来
 *
 * 建议初值：
 * 12 ~ 18 度
 */
#define YAW_LIMIT_DEG               (15.0f)

/*
 * 分段增益阈值（单位：像素）
 * 含义：当偏差较小时，稍微灵敏一点；
 *      当偏差较大时，反而不要过猛
 *
 * 例如：
 * abs(offset) < 15 像素 -> 用小偏差增益
 * abs(offset) >= 15 像素 -> 用大偏差增益
 */
#define SMALL_OFFSET_THRESHOLD_PX   (15)

/*
 * 小偏差附加增益
 * 作用：在目标接近中心但仍有偏差时，提高微调能力
 */
#define SMALL_OFFSET_GAIN           (1.15f)

/*
 * 大偏差附加增益
 * 作用：目标偏得很远时，避免一下子给太猛
 */
#define LARGE_OFFSET_GAIN           (0.95f)


//====================================================
// 二、基础数学工具函数
//====================================================

/*
 * 角度转弧度
 * 因为 C 语言三角函数使用的是弧度
 */
static float deg_to_rad(float deg)
{
    return deg * 3.1415926f / 180.0f;
}

/*
 * 弧度转角度
 * 因为控制里通常更习惯用“度”
 */
static float rad_to_deg(float rad)
{
    return rad * 180.0f / 3.1415926f;
}

/*
 * 取绝对值
 * 这里自己写一个，避免某些编译环境下 abs/fabsf 使用不方便
 */
static int abs_int(int x)
{
    return (x >= 0) ? x : (-x);
}

/*
 * 浮点限幅函数
 * 把 value 限制在 [min_val, max_val] 范围内
 */
static float clamp_float(float value, float min_val, float max_val)
{
    if(value > max_val) return max_val;
    if(value < min_val) return min_val;
    return value;
}


//====================================================
// 三、核心函数：offset -> yaw
//====================================================

/*
 * 函数名称：offset_to_yaw
 * 参数说明：
 *   offset:
 *      图像目标中心相对于图像中线的横向偏差（单位：像素）
 *
 *      一般约定：
 *      offset = target_x - image_center_x
 *
 *      例如：
 *      - offset > 0 ：目标在图像右侧
 *      - offset < 0 ：目标在图像左侧
 *
 * 返回值：
 *   yaw（单位：度）
 *
 * 含义：
 *   视觉层建议车头修正的相对角度
 *
 * 设计过程：
 *   1. 先根据相机水平视场角计算等效焦距 fx
 *   2. 用 atan(offset / fx) 把像素偏差转成几何角度
 *   3. 再乘工程增益，让实际车辆更好开
 *   4. 做死区和限幅，保证稳定性
 */
float offset_to_yaw(int offset)
{
    float hfov_rad;         // 水平视场角（弧度）
    float fx;               // 等效焦距（像素单位）
    float yaw_deg;          // 最终输出 yaw（度）
    int abs_offset;         // 偏差绝对值

    //------------------------------------------------
    // 1. 中心死区：目标基本居中时，不输出 yaw，避免左右抖动
    //------------------------------------------------
    if(offset > -OFFSET_DEADBAND_PX && offset < OFFSET_DEADBAND_PX)
    {
        return 0.0f;
    }

    //------------------------------------------------
    // 2. 根据摄像头水平视场角，计算等效焦距 fx
    //
    // 公式：
    // fx = (图像宽度 / 2) / tan(HFOV / 2)
    //
    // 含义：
    // 把“图像像素偏差”转换成“成像角度”
    //
    // 注意：
    // fx 是相机参数，不会随着锥桶位置变化
    //------------------------------------------------
    hfov_rad = deg_to_rad(CAMERA_HFOV_DEG);
    fx = (PROJECT_ONE_IMAGE_W * 0.5f) / tanf(hfov_rad * 0.5f);

    //------------------------------------------------
    // 3. 用反正切计算几何偏差角
    //
    // yaw = atan(offset / fx)
    //
    // 这一步比简单线性映射更符合成像几何
    //------------------------------------------------
    yaw_deg = rad_to_deg(atanf((float)offset / fx));

    //------------------------------------------------
    // 4. 乘全局增益
    //
    // 说明：
    // 因为真实车的运动、摩擦、控制环响应都不是理想几何，
    // 所以工程上通常会乘一个增益，让“视觉角度”更适合实际控制。
    //------------------------------------------------
    yaw_deg *= YAW_GAIN;

    //------------------------------------------------
    // 5. 分段增益优化
    //
    // 目的：
    // - 小偏差时更灵敏，便于微调
    // - 大偏差时别太猛，避免剧烈摆动
    //------------------------------------------------
    abs_offset = abs_int(offset);

    if(abs_offset < SMALL_OFFSET_THRESHOLD_PX)
    {
        yaw_deg *= SMALL_OFFSET_GAIN;
    }
    else
    {
        yaw_deg *= LARGE_OFFSET_GAIN;
    }

    //------------------------------------------------
    // 6. 限幅
    //
    // 防止瞬间给太大角度，造成：
    // - 摆头
    // - 过冲
    // - 平衡不稳
    //------------------------------------------------
    yaw_deg = clamp_float(yaw_deg, -YAW_LIMIT_DEG, YAW_LIMIT_DEG);

    //------------------------------------------------
    // 7. 返回最终 yaw
    //------------------------------------------------
    return yaw_deg;
}